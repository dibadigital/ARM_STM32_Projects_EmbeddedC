<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\UpCounter1Digit7SegmentCC_IAR.ewp</path>
  </project>
  <batchBuild />
</workspace>
