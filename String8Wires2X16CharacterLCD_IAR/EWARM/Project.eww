<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\String8Wires2X16CharacterLCD_IAR.ewp</path>
  </project>
  <batchBuild />
</workspace>
